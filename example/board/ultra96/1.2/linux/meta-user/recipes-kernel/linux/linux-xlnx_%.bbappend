SRC_URI += "file://user.cfg \
            file://user_2020-01-02-12-01-00.cfg \
            file://user_2020-01-02-20-28-00.cfg \
            file://user_2020-01-03-11-05-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

