
YAML_SERIAL_CONSOLE_STDOUT_forcevariable = "psu_uart_1"
YAML_SERIAL_CONSOLE_STDIN_forcevariable = "psu_uart_1"
